<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("0123456789012345678901234567890123456789012345678901234567890123456789012345678901234567890123456789")</value></param>
<param><key>num</key><value>250</value></param>
<param><key>interval</key><value>500</value></param>
<param><key>quit</key><value>True</value></param>
</block>
<connection><source_block_id>foo_periodic_msg_source_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
